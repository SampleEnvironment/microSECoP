## examples/esp32-wt32eth01/sdkconfig.defaults
```kconfig
CONFIG_ESP_MAIN_TASK_STACK_SIZE=8000
CONFIG_PTHREAD_TASK_STACK_SIZE_DEFAULT=8000
CONFIG_ESP_SYSTEM_EVENT_TASK_STACK_SIZE=8000
```
